# Copyright (C) 2022, Octavo Systems - All Rights Reserved
# Released under the MIT license (see COPYING.MIT for the terms)

# Replaces mount-partitions.sh with the correct mmc interface for eMMC(mmcblk2)
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
