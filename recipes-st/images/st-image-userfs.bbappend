PACKAGE_INSTALL += "brkdemo-userfs"
