FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0023-Add-OSD32MP1-BRK-board-support.patch \
	    file://0024-Add-OSD32MP1-RED-Device-tree-support.patch \
	    file://0025-Fix-device-tree-for-800MHz-speedgrade-MP1-to-work-wi.patch \
	    file://0026-Add-OSD32MP1-RED-V1_2-Device-tree-support.patch"
