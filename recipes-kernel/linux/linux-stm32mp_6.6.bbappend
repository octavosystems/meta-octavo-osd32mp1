FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-DT-support-for-OSD32MP1-BRK.patch"

