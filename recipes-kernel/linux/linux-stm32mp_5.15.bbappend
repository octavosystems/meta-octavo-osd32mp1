FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0023-Add-Device-Tree-support-for-OSD32MP1-BRK.patch \
	    file://0024-Add-Device-Tree-support-for-OSD32MP1-RED.patch \
	    file://0025-Fix-device-tree-for-800MHz-speedgrade-MP1-to-work-wi.patch"
