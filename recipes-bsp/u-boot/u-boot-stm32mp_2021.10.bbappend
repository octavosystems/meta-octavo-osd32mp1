FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0006-Add-Device-Tree-support-for-OSD32MP1-BRK.patch \
	    file://0007-Add-board-support-for-OSD32MP1-BRK.patch \
	    file://0008-Add-Device-Tree-support-for-OSD32MP1-RED.patch \
	    file://0009-Fix-device-tree-for-800MHz-speedgrade-MP1-to-work-wi.patch"
