FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-OSD32MP1-BRK-Device-tree-support.patch \
	    file://0002-Add-OSD32MP1-RED-Device-tree-support.patch \
	    file://0003-Fix-device-tree-for-800MHz-speedgrade-MP1-to-work-wi.patch"
