FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0002-Add-Device-Tree-support-for-OSD32MP1-BRK.patch \
	    file://0003-Add-Device-Tree-support-for-OSD32MP1-RED.patch \
	    file://0004-Fix-device-tree-for-800MHz-speedgrade-MP1-to-work-wi.patch \
	    file://0005-Add-OSD32MP1-RED-V1_2-Device-tree-support.patch"
