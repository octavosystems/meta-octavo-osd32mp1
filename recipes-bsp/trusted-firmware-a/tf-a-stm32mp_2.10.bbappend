FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0004-Add-OSD32MP1-BRK-board-support.patch"

