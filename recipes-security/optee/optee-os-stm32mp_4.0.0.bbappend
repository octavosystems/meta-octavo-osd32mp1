FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0002-Add-support-for-OSD32MP1-RED.patch file://0001-Add-support-for-OSD32MP1-BRK.patch"

